# Keil uVision project blinky.uvprojx, settings and files
target Target_1 (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: AudioUSB
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Lab03_AudioUSB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6314W
  group Source Group 1
    ./: main.c
  group lib
    ./: stm32l476xx.h GPIO.h GPIO.c
software components: RTOS:Config 11.1.0, RTOS:Core 11.1.0, RTOS:Event Groups 11.1.0, RTOS:Heap 11.1.0, RTOS:Timers 11.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.1.0, Device:Startup 1.3.2
